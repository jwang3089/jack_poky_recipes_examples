inherit jack_image_types 
IMAGE_FSTYPES_append = " jackwang jacknext_4 "
