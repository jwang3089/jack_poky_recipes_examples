IMAGE_INSTALL_append = " packagegroup-jackwang-apps " 
