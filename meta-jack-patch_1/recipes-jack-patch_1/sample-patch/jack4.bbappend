FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI +="file://main.patch \
          "
